# Keil uVision project SYD8811_BLE_LoRa_Lock_V01.uvprojx, settings and files
target SYD8811 (6190010::V6.19::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: Ble_Vendor_Service +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\Ble_Vendor_Service.hex"
  AfterMake: fromelf -c  .\output\Ble_Vendor_Service.axf  -o  .\output\Ble_Vendor_Service_assembly.txt
  c include: ..\..\..\Include;..\..\..\BLE;..\..\..\Lib;..\profile;..\;..\..\..\RTT;..\UserApp
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3f000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group Main
    ../: main.c
    ../../../Driver/: delay.c
  group User
    ../UserApp/: user_app.c battery.c led.c input.c motor.c os_timer.c my_aes.c UART_T.c e220_driver.c
  group Driver
    ../../../ble/: ota.c
    ../../../Driver/: gpio.c gpadc.c wdt.c pwm.c
    ../: timer_handler.c rtc_handler.c flash.c
  group BLE
    ../../../Lib/: syd8811_ble_lib.lib Syd8811_softtimer_lib.lib
  group RTT
    ../../../Rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
