# Keil uVision project SYD8811_BLE_LoRa_Lock_V01.uvprojx, settings and files
target SYD8811 (6240000::V6.24::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: SYD8811_BLE_LoRa_Lock +hex
  c flags: Optim=2 OneElfS=1
  c define: _DEBUG_, _SYD_RTT_DEBUG_
  c misc: -fno-strict-aliasing
  c include: ..\include;..\include\driver;..\include\ble;..\src
  library: MicroLIB
  group Application
    ../src/: main.c user_app.c e220_driver.c
  group Driver
    ../src/: led.c motor.c input.c battery.c flash.c os_timer.c my_aes.c timer_handler.c rtc_handler.c uart.c uart_protocol.c UART_T.c common.c delay.c gpio.c spi.c gpadc.c
  group CMSIS
    ./RTE/Device/ARMCM0/: system_ARMCM0.c startup_ARMCM0.s
  group BLE
    ../lib/: syd8811_ble_lib.lib
  group RTT
    ../src/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Lib
    ../lib/: Syd8811_softtimer_lib.lib
